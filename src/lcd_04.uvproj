# Keil uVision project lcd_04.uvproj, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: LPC2138 NXP
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: lcd_04 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Source Group 1
    ./: Startup.s dev_oper.c io_lib.c lcd.c keyboard.c main.c sw_lib.c appl_conf.h constants.h data_ids_map.h dev_chs_map.h dev_oper.h io_conf.h io_lib.h lcd.h keyboard.h main.h port.h sw_lib.h uart.c uart.h appl.h appl.c std_lib.c std_lib.h sys_status.h
